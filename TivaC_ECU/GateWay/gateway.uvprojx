# Keil uVision project gateway.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gateway
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bl_config.h can_driver.h CAN_HW_TYPES.h CAN_PORT.h common.h hw_can.h hw_types.h Packet.h sysctl.h tm4c123gh6pm.h
    ./keil4/: bl_CAN.c can_driver.c GW_main.c sysctl.c bl_CAN.h
    ./RTE/Device/TM4C123GH6PM/: startup_TM4C123.s
