# Keil uVision project Bootloader.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\new_scatter.sct
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: bl_flash.c Bl_main.c bl_uart.c Packet.c sysctl.c Startup.s can_driver.c bl_CAN.c interrupt.c GPIO.c cpu.c Pll.c eeprom.c MapComDevice.h
